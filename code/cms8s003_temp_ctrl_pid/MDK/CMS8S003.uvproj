# Keil uVision project CMS8S003.uvproj, settings and files
target CMS8S003 (MCS-51)
  device: CMS8S003 CMS
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(50000000) MOD517AU MODDP2
  output: CMS8S003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP;..\DERIVE;..\HAL
  link misc: REMOVEUNUSED
  group APP
    ../APP/: main.c test.c fun.c tempCtrl.c autoCalibration.c protocol.c pid.c encryption.c
  group DRIVE
    ../DERIVE/: delay.c mch.c ntc.c siliconControl.c
  group HAL
    ../HAL/: hal_adc.c hal_buzzer.c hal_flash.c hal_key.c hal_pwm.c hal_sys.c hal_time.c hal_uart.c
  group CMSIS
    ./: STARTUP.A51
  group README
    ../: README.md
  group PREADME
    ../../../: README.md
